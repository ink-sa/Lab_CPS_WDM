# Keil uVision project Lab_CPS_WDM.uvproj, settings and files
target WDM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab_CPS_WDM +hex
  c flags: Optim=1
  c include: ..\Lab_CPS_WDM;.\Sturtup;.\User;.\CMSIS\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Sturtup
    ./: startup_stm32f4xx.s
    ./Sturtup/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group User
    ./User/: main.c periph_init.c periph_init.h functions.c functions.h interrupt_heandler.c interrupt_heandler.h main.h
  group StdPeriph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
